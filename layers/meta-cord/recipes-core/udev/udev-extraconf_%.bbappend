# Change the mount base to /media instead of /run/media just so it is a bit more
# like a traditional Linux system
MOUNT_BASE = "/media"
