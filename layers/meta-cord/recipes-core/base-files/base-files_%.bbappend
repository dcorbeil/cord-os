FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

# Example of how to change the hostname
# hostname:pn-base-files:beaglebone-black = "cord-os-bboneblack"
